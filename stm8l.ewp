# IAR project stm8l.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151K4 STM8L151K4
  General.GenCodeModel: 1
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: STM8l_StdPeriph_Driver\inc; APP
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8l.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group APP
    APP/: flashbatt.c flashbatt.h ledbeeplcd.c ledbeeplcd.h main.c main.h oledfont.h sensoradc.c sensoradc.h stm8l15x_it.c stm8l15x_it.h temhum.c temhum.h
  group STM8l_StdPeriph_Driver
    STM8l_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_rtc.c stm8l15x_tim2.c stm8l15x_usart.c stm8l15x_wwdg.c
